# Repository kaz19610303/SPRESENSE_CAN

File README.md:

# SPRESENSE_CAN
Sony Spresense用の***CANインターフェースボード***です。　　
  
このボードに使用しているCANインタフェースICは***Microchip***社の***MCP2515T-E_ST***です。  
MCP2515は、第2世代のスタンドアロンCANコントローラです。MCP2510とピンおよび機能の互換性があり、より高速なスループット、データバイト・フィルタリング、タイムトリガー・プロトコルのサポートなどのアップグレードされた機能が含まれています。  
詳しくは以下のデータシートをご覧下さい。  
[MCP2515 データシート](https://www.mouser.jp/datasheet/2/268/MCP2515-Stand-Alone-CAN-Controller-with-SPI-200018-708845.pdf)  
  
回路図とEagle用のデータはGithubにて公開しています。  
[kaz19610303/SPRESENSE_CAN](https://github.com/kaz19610303/SPRESENSE_CAN)  
  
ジャンパー設定  
SJ1　INTピン選択　1: EMMC_DATA2　3:I2S_LRCK  
SJ2　csピン選択　 1: I2S_DIN　   3:SPI_CS  
SJ3　ショートで終端抵抗有効

## EAGLE design hardware/eagle_data/CAN.brd

Parts:
C1, C2: 4.7uF; C0603K
C3, C7: 10uF; C0603
C4, C8: 1uF; C0603K
C5, C6: 18pF; C0603
C9: 0.1uF; C0603K
IC1: TXB0106RGYR; SN74CBT3257CRGYR
IC2: MCP2515T-E_ST; SOP65P640X120-20N
IC3: MCP1700T-3302E_TT; SOT95P237X112-3N
IC4: MCP2551T-E_SN; SOIC127P600X175-8N
J1: 1776112-2; SHDR2W90P0X348_1X2_700X730X850
JP1, JP2: JUMPER-SMT_3_NO_NO-SILK; SMT-JUMPER_3_NO_NO-SILK
JP3: JUMPER-SMT_2_NC_PASTE_NO-SILK; SMT-JUMPER_2_NC_PASTE_NO-SILK
R1, R2, R3: 10K 1/10W; R0603
R4: 120 1/10W; R0603
SV1, SV2: FE13-1; FE13
X1: 8Mhz; HC49UP

Connections:
1V8: C1.2, IC1.2 (VCCA), IC1.8 (OE), SV2.2
1V8*: SV1.11
3.3V: C2.1, C3.1, C7.1, C8.1, C9.1, IC1.15 (VCCB), IC2.20 (VDD), IC3.2 (VOUT), IC4.3 (VDD), R1.2, R2.2, R3.2
+3V3*: SV1.10
/CS: IC1.10 (B6), IC2.18 (!CS), R2.1
/INT: IC1.14 (B2), IC2.13 (!INT), R1.1
CANH: IC4.7 (CANH), J1.1, R4.1
CANL: IC4.6 (CANL), J1.2, JP3.1
CTS: SV1.5
EMMC_DATA2: JP1.1, SV2.5
EMMC_DATA3: SV2.4
EXT_VDD: C4.1, IC3.3 (VIN), SV2.3
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, IC1.1 (A1), IC1.9 (GND), IC1.16 (B1), IC1.17 (EP), IC2.10 (VSS), IC3.1 (GND), IC4.2 (VSS), IC4.8 (RS), SV1.1, SV2.10
I2C_SCL: SV2.11
I2C_SDA: SV2.12
I2S_BCK: SV1.6
I2S_DIN: JP2.1, SV2.6
I2S_DOUT: SV2.7
I2S_LRCK: JP1.3, SV1.7
unnamed: IC2.1 (TXCAN), IC4.1 (TXD)
unnamed: IC2.2 (RXCAN), IC4.4 (RXD)
unnamed: IC1.7 (A6), JP2.2
unnamed: IC1.3 (A2), JP1.2
unnamed: C5.1, IC2.8 (OSC2), X1.P$2
unnamed: C6.1, IC2.9 (OSC1), X1.P$1
unnamed: JP3.2, R4.2
unnamed: IC2.19 (!RESET), R3.1
RTS: SV1.4
RX: SV1.3
SCK: IC1.13 (B3), IC2.14 (SCK)
SEN_AIN4: SV1.13
SEN_AIN5: SV2.13
SEN_IRQ_IN: SV1.12
SI: IC1.12 (B4), IC2.16 (SI)
SO: IC1.11 (B5), IC2.17 (SO)
SPI_CS: JP2.3, SV1.8
SPI_MISO: IC1.6 (A5), SV2.8
SPI_MOSI: IC1.5 (A4), SV2.9
SPI_SCK: IC1.4 (A3), SV1.9
TX: SV1.2
XRST_PIN_1.8V: SV2.1

Notes on the sheet:
1.8V ⇔ 3.3V レベルコンバーター
スタッカブル用
CAN Controlor
Sony Spresense
NS-SPR-0303
TLE7251VSJXUMA1

Board: 2 copper layers, 21.6 x 50.0 mm, 24 parts (1 on the bottom side), 26 nets.

File hardware/bom/can_bom.xlsx:

Parts | Qty | Value | Package | Description | MANUFACTURER_NAME | MANUFACTURER_PART_NUMBER
C1, C2 | 2 | 4.7uF +/-10% 10V | C0603K | CAPACITOR, European symbol | Samsung Electro-Mechanics | CL10A475KP8NNNC
C3, C7 | 2 | 10uF +/-10% 10V | C0603 | 302010142 | Yageo | CC0603JRNPO9BN270
C4, C8 | 2 | 1uF +/-10% 10V | C0603K | CAPACITOR, European symbol | Taiyo Yuden | LMK107B7105KA-T
C5, C6 | 2 | 18pF +/-1% 10V | C0603 | 302010142 | Yageo | CC0603JRNPO9BN270
C9 | 1 | 0.1uF+/-10% 10V | C0603K | CAPACITOR, European symbol | Taiyo Yuden | EMK063BJ104MP-F
IC1 | 1 | TXB0106RGYR | SN74CBT3257CRGYR | Translation - Voltage Levels 8B Bidirec Vltg-Lev Translator | Texas Instruments | TXB0106RGYR
IC2 | 1 | MCP2515T-E_ST | SOP65P640X120-20N | CAN Interface IC W/ SPI Inter 125dC | Microchip | MCP2515T-E/ST
IC3 | 1 | MCP1700T-3302E_TT | SOT95P237X112-3N | LDO voltage regulator 250mA Isupply 1uA | Microchip | MCP1700T-3302E/TT
IC4 | 1 | MCP2551T-E_SN | SOIC127P600X175-8N | CAN Interface IC Hi Spd CAN Transceiv | Microchip | MCP2551T-E/SN
J1 | 1 | 1776112-2 | SHDR2W90P0X348_1X2_700X730X850 | Conn Eurostyle Block 2 POS 3.5mm Solder ST Thru-Hole 12A/Contact | TE Connectivity | 1776112-2
R1, R2, R3 | 3 | 10K +/-5% 1/10W | R0603 | 301010293 | Yageo | RC0603JR-0710KL
R4 | 1 | 120 +/-5% 1/10W | R0603 | 301010293 | Yageo | RC0603JR-7W120RL
X1 | 1 | 8Mhz | HC49UP | SMD Crystal 8Mhz-18pF-20ppm-40R;HC49UP | ECS | ECS-080-18-5PX-JES-TR
JP1, JP2 | 2 | JUMPER-SMT_3_NO_NO-SILK | SMT-JUMPER_3_NO_NO-SILK | Normally open jumper
JP3 | 1 | JUMPER-SMT_2_NC_PASTE_NO-SILK | SMT-JUMPER_2_NC_PASTE_NO-SILK | Normally closed solder jumper
SV1, SV2 | 2 |  | FE13 | FEMALE HEADER

## Commit log

2021-01-19 First commit.

Notices in the files:
parts and their libraries:
SparkFun-Jumpers: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
